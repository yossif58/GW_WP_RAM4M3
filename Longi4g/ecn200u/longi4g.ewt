<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>build</name>
    <file>
      <name>$PROJ_DIR$\build_all.bat</name>
    </file>
    <file>
      <name>$PROJ_DIR$\india4g.bat</name>
    </file>
    <file>
      <name>$PROJ_DIR$\indianoclean4g.bat</name>
    </file>
  </group>
  <group>
    <name>inc</name>
    <file>
      <name>$PROJ_DIR$\components\ql-application\Longi4G\inc\crc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\components\ql-application\Longi4G\inc\longi4g.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\components\ql-application\Longi4G\inc\longi_nor_flash.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\components\ql-application\Longi4G\inc\longi_uart.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\components\ql-application\Longi4G\inc\LongiWrapper.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\components\ql-application\Longi4G\inc\ql_uart.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\components\ql-application\Longi4G\inc\sms_demo.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\components\ql-application\Longi4G\inc\socket_demo.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\components\ql-application\Longi4G\inc\utils.h</name>
    </file>
  </group>
  <group>
    <name>log</name>
    <file>
      <name>$PROJ_DIR$\india4g.log</name>
    </file>
  </group>
  <group>
    <name>longi4g_products</name>
    <file>
      <name>$PROJ_DIR$\out\8915DM_cat1_open_release\hex\8915DM_cat1_open-cat1_UIS8915DM_BB_RF_SS_NoVolte_cus-release.pac</name>
    </file>
    <file>
      <name>$PROJ_DIR$\target\ec200ucn_aa_APPIMAG2\app\APPIMAG2_APP.map</name>
    </file>
    <file>
      <name>$PROJ_DIR$\out\8915DM_cat1_open_release\hex\examples\APPIMAG2_APP.pac</name>
    </file>
  </group>
  <group>
    <name>make</name>
    <file>
      <name>$PROJ_DIR$\components\ql-application\Longi4G\CMakeLists.txt</name>
    </file>
  </group>
  <group>
    <name>quectel_init</name>
    <file>
      <name>$PROJ_DIR$\components\ql-application\init\CMakeLists.txt</name>
    </file>
    <file>
      <name>$PROJ_DIR$\components\ql-application\ql_app_feature_config.cmake</name>
    </file>
    <file>
      <name>$PROJ_DIR$\components\ql-application\ql_app_feature_config.h.in</name>
    </file>
    <file>
      <name>$PROJ_DIR$\components\ql-application\init\ql_init.c</name>
    </file>
  </group>
  <group>
    <name>src</name>
    <file>
      <name>$PROJ_DIR$\components\ql-application\Longi4G\crc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\components\ql-application\Longi4G\DLMScrc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\components\ql-application\Longi4G\DLMSProtocol.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\components\ql-application\Longi4G\embed_nor_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\components\ql-application\Longi4G\LongiMain.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\components\ql-application\Longi4G\sms_demo.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\components\ql-application\Longi4G\socket_demo.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\components\ql-application\Longi4G\uart_longi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\components\ql-application\Longi4G\utils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\components\ql-application\Longi4G\Wrapper.c</name>
    </file>
  </group>
</project>


