# IAR project longi4g.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: longi4g.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group build
    ./: build_all.bat india4g.bat indianoclean4g.bat
  group inc
    components/ql-application/Longi4G/inc/: crc.h longi4g.h longi_nor_flash.h longi_uart.h LongiWrapper.h ql_uart.h sms_demo.h socket_demo.h utils.h
  group log
    ./: india4g.log
  group longi4g_products
    out/8915DM_cat1_open_release/hex/: 8915DM_cat1_open-cat1_UIS8915DM_BB_RF_SS_NoVolte_cus-release.pac
    target/ec200ucn_aa_APPIMAG2/app/: APPIMAG2_APP.map
    out/8915DM_cat1_open_release/hex/examples/: APPIMAG2_APP.pac
  group make
    components/ql-application/Longi4G/: CMakeLists.txt
  group quectel_init
    components/ql-application/init/: CMakeLists.txt ql_init.c
    components/ql-application/: ql_app_feature_config.cmake ql_app_feature_config.h.in
  group src
    components/ql-application/Longi4G/: crc.c DLMScrc.c DLMSProtocol.c embed_nor_flash.c LongiMain.c sms_demo.c socket_demo.c uart_longi.c utils.c Wrapper.c
